Properties of the parts of a building model (IFC4X3)

# File
Description: ViewDefinition [CoordinationView], RevitIdentifiers [ContentGUID: , VersionGUID: 478dc6d8-ad5e-43c6-a510-9f3fb974ffbf, NumberOfSaves: 8], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Internal]
File name: 01K118-KSI-XX-ZZ-M3-Z-0001.ifc
Time: 2025-06-11T14:00:36+00:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.60.36 (ENG) - IFC 23.4.0.0

# IfcProject, Project Number
LongName: Kingspan Kooltherm® K118

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information
Pset_SpaceCommon - Reference: Project Information; IsExternal: no
Other - Category: Project Information; Project Address: Enter address here; Project Name: Kingspan Kooltherm® K118; Project Number: Project Number
Identity Data - Author: CM; Organization Name: Kingspan Insulation Ltd

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no; sets with these values: 2
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2
Other - Category: Project Information; Project Address: Enter address here; Project Name: Kingspan Kooltherm® K118; Project Number: Project Number
Identity Data - Author: CM; Organization Name: Kingspan Insulation Ltd

# IfcBuildingStorey: Level:Circle Head - Project Datum (2)
Pset_BuildingStoreyCommon - Reference: Level:Circle Head - Project Datum
Pset_SpaceCommon - IsExternal: no; Reference: Level:Circle Head - Project Datum
Other - Category: Levels; Family: Level; Family and Type: Level: Circle Head - Project Datum; Type: Circle Head - Project Datum; Type Id: 305
Dimensions - Computation Height: 0 mm
Identity Data - Structural: no; Building Story: yes
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: Anno_Level_Head_Circle : Standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: no
Identity Data(Type) - Type Name: Circle Head - Project Datum
Name | LongName = Name | Elevation (mm) = Constraints, Elevation (mm)
Level 0 | Level 0 | 0
Level 1 | Level 1 | 4000

# IfcBuildingElementProxy: Generic Models : Model Text : 600mm KI_CenturyGothic (8)
In: Level 0
Type - Other - Category: Generic Models; Family Name: Model Text
Type - Identity Data - Type Name: 600mm KI_CenturyGothic
Type - Text - Bold: no; Italic: no; Text Font: Century Gothic; Text Size: 600 mm
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: Model Text:600mm KI_CenturyGothic
Pset_EnvironmentalImpactIndicators - Reference: Model Text:600mm KI_CenturyGothic
Other - Family: Model Text; Family and Type: Model Text: 600mm KI_CenturyGothic; Type: 600mm KI_CenturyGothic; Type Id: 305799
Constraints - Work Plane: Level : Level 0
Dimensions - Depth: 150 mm
Graphics - Horizontal Align: Left
Identity Data - Subcategory: Generic Models
Phasing - Phase Created: New Construction
Name (Generic Models : Model Text :...) | Text
 600mm KI_CenturyGothic | Kingspan Kooltherm K118 - 37.5mm
 600mm KI_CenturyGothic | Kingspan Kooltherm K118 - 42.5mm
 600mm KI_CenturyGothic | Kingspan Kooltherm K118 - 52.5mm
 600mm KI_CenturyGothic | Kingspan Kooltherm K118 - 57.5mm
 600mm KI_CenturyGothic | Kingspan Kooltherm K118 - 62.5mm
 600mm KI_CenturyGothic | Kingspan Kooltherm K118 - 72.5mm
 600mm KI_CenturyGothic | Kingspan Kooltherm K118 - 82.5mm
 600mm KI_CenturyGothic | Kingspan Kooltherm K118 - 92.5mm

# IfcCovering: Walls : Basic Wall : KingspanInsulation_Insulation_Kooltherm-K118-Insulated-Plasterboard-37.5
In: Level 0
Type - PredefinedType: USERDEFINED; Material: KingspanInsulation01GB_Plasterboard_Kooltherm-K118-Insulated-Plasterboard-12.5 12.5 mm, KingspanInsulation01GB_Insulation_Kooltherm-K118-Insulated-Plasterboard-25 25 mm
Type - Other - Category: Walls; Family Name: Basic Wall
Type - Construction - Function: Interior; Width: 37.5 mm; Wrapping at Inserts: Both
Type - Dimensions - Length: 2400mm; Thickness: 37.5mm; Width: 1200mm
Type - Graphics - Coarse Scale Fill Color: 12632256; Coarse Scale Fill Pattern: <Solid fill>
Type - Identity Data - Assembly Code: n/a; BondedProductThermalConductivity: 0.19 (W/mK); ClassificationCode: Pr_25_71_35_88, Pr_25_71_63_59; ClassificationSystem: Uniclass; ClassificationTitle: Thermal laminate gypsum plasterboards, Phenolic foam boards; ClassificationVersion: 01/04/2023; Description: Insulated plasterboard for mechanically fixed and adhesively bonded insulated drylining.; Fire Rating: To BS EN 13501-1: 2018, Euroclass RtF B-s1,d0; HealthAndSafetyInformation: https://www.kingspan.com/content/dam/kingspan/kil/products/general-gb-and-ireland/kingspan-kooltherm-safety-information-en-gb-ie.pdf; InstallationGuidance: https://www.kingspan.com/content/dam/kingspan/kil/products/kooltherm-k118-insulated-plasterboard-gb-and-ireland/kingspan-kooltherm-k118-brochure-en-gb.pdf; Manufacturer: Kingspan Insulation; ManufacturingFacility: This product is manufactured at Kingspan's Pembridge, Herefordshire manufacturing facility.; Model: K118; ProductDataSheet: https://ks-kentico-prod-cdn-endpoint.azureedge.net/bimstorage/K118.37.5mm.BIM-1075.V1.pdf; ThermalConductivity: 0.019 (W/mK); Type Comments: K118-37.5mm; Type Mark: n/a; Type Name: KingspanInsulation_Insulation_Kooltherm-K118-Insulated-Plasterboard-37.5; URL: https://www.kingspan.com/gb/en/products/insulation-boards/wall-insulation-boards/kooltherm-k118-insulated-plasterboard/; Version: 1
Type - Analytical Properties - Absorptance: 0.7; Heat Transfer Coefficient (U): 0.72381 kg/K/s3; Roughness: 3; Thermal Mass: 0 kg/K/s2; Thermal Resistance (R): 1.38158 s3*K/kg
Type - Pset_CoveringCommon - ThermalTransmittance: 0.72381 kg/K/s3; FireRating: To BS EN 13501-1: 2018, Euroclass RtF B-s1,d0
Type - Pset_ManufacturerTypeInformation - Manufacturer: Kingspan Insulation
Classification: Pr_25_71_35_88, Pr_25_71_63_59 (Default Classification); n/a (Uniformat)
Pset_CoveringCommon - IsExternal: no; Reference: Basic Wall:KingspanInsulation_Insulation_Kooltherm-K118-Insulated-Plasterboard-37.5
Pset_EnvironmentalImpactIndicators - Reference: Basic Wall:KingspanInsulation_Insulation_Kooltherm-K118-Insulated-Plasterboard-37.5
Wall Schedule - Type: KingspanInsulation_Insulation_Kooltherm-K118-Insulated-Plasterboard-37.5; Version: 1; Export Type to IFC As: IfcCoveringType; Type IFC Predefined Type: USERDEFINED; ClassificationSystem: Uniclass; ClassificationCode: Pr_25_71_35_88, Pr_25_71_63_59; ClassificationTitle: Thermal laminate gypsum plasterboards, Phenolic foam boards; ClassificationVersion: 01/04/2023; Model: K118; Manufacturer: Kingspan Insulation; Type Comments: K118-37.5mm; URL: https://www.kingspan.com/gb/en/products/insulation-boards/wall-insulation-boards/kooltherm-k118-insulated-plasterboard/; Description: Insulated plasterboard for mechanically fixed and adhesively bonded insulated drylining.; Assembly Code: n/a; Type Mark: n/a; Fire Rating: To BS EN 13501-1: 2018, Euroclass RtF B-s1,d0; Length: 1200; Width: 38; Thickness: 37.5mm; ThermalConductivity: 0.019 (W/mK); BondedProductThermalConductivity: 0.19 (W/mK); InstallationGuidance: https://www.kingspan.com/content/dam/kingspan/kil/products/kooltherm-k118-insulated-plasterboard-gb-and-ireland/kingspan-kooltherm-k118-brochure-en-gb.pdf; HealthAndSafetyInformation: https://www.kingspan.com/content/dam/kingspan/kil/products/general-gb-and-ireland/kingspan-kooltherm-safety-information-en-gb-ie.pdf; ProductDataSheet: https://ks-kentico-prod-cdn-endpoint.azureedge.net/bimstorage/K118.37.5mm.BIM-1075.V1.pdf; ManufacturingFacility: This product is manufactured at Kingspan's Pembridge, Herefordshire manufacturing facility.
Other - Family: Basic Wall; Family and Type: Basic Wall: KingspanInsulation_Insulation_Kooltherm-K118-Insulated-Plasterboard-37.5; Type: KingspanInsulation_Insulation_Kooltherm-K118-Insulated-Plasterboard-37.5; Type Id: 307305
Constraints - Base Constraint: Level 0; Base Extension Distance: 0 mm; Base is Attached: no; Base Offset: 0 mm; Location Line: Wall Centerline; Related to Mass: no; Room Bounding: yes; Top Extension Distance: 0 mm; Top is Attached: no; Top Offset: 0 mm; Unconnected Height: 2400 mm
Dimensions - Area: 2.88 m2; Length: 1200 mm; Volume: 0.108 m3
Phasing - Phase Created: New Construction
Structural - Structural: no; Structural Usage: Non-bearing
Cross-Section Definition - Cross-Section: Vertical

# IfcCovering: Walls : Basic Wall : KingspanInsulation_Insulation_Kooltherm-K118-Insulated-Plasterboard-42.5
In: Level 0
Type - PredefinedType: USERDEFINED; Material: KingspanInsulation01GB_Plasterboard_Kooltherm-K118-Insulated-Plasterboard-12.5 12.5 mm, KingspanInsulation01GB_Insulation_Kooltherm-K118-Insulated-Plasterboard-30 30 mm
Type - Other - Category: Walls; Family Name: Basic Wall
Type - Construction - Function: Interior; Wrapping at Inserts: Both; Width: 42.5 mm
Type - Dimensions - Length: 2400mm; Thickness: 42.5mm; Width: 1200mm
Type - Graphics - Coarse Scale Fill Pattern: <Solid fill>; Coarse Scale Fill Color: 12632256
Type - Identity Data - Assembly Code: n/a; BondedProductThermalConductivity: 0.19 (W/mK); ClassificationCode: Pr_25_71_35_88, Pr_25_71_63_59; ClassificationSystem: Uniclass; ClassificationTitle: Thermal laminate gypsum plasterboards, Phenolic foam boards; ClassificationVersion: 01/04/2023; Description: Insulated plasterboard for mechanically fixed and adhesively bonded insulated drylining.; Fire Rating: To BS EN 13501-1: 2018, Euroclass RtF B-s1,d0; HealthAndSafetyInformation: https://www.kingspan.com/content/dam/kingspan/kil/products/general-gb-and-ireland/kingspan-kooltherm-safety-information-en-gb-ie.pdf; InstallationGuidance: https://www.kingspan.com/content/dam/kingspan/kil/products/kooltherm-k118-insulated-plasterboard-gb-and-ireland/kingspan-kooltherm-k118-brochure-en-gb.pdf; Manufacturer: Kingspan Insulation; ManufacturingFacility: This product is manufactured at Kingspan's Pembridge, Herefordshire manufacturing facility.; Model: K118; ProductDataSheet: https://ks-kentico-prod-cdn-endpoint.azureedge.net/bimstorage/K118.42.5mm.BIM-1076.V1.pdf; ThermalConductivity: 0.019 (W/mK); Type Comments: K118-42.5mm; Type Mark: n/a; Type Name: KingspanInsulation_Insulation_Kooltherm-K118-Insulated-Plasterboard-42.5; URL: https://www.kingspan.com/gb/en/products/insulation-boards/wall-insulation-boards/kooltherm-k118-insulated-plasterboard/; Version: 1
Type - Analytical Properties - Absorptance: 0.7; Roughness: 3; Heat Transfer Coefficient (U): 0.608 kg/K/s3; Thermal Mass: 0 kg/K/s2; Thermal Resistance (R): 1.64474 s3*K/kg
Type - Pset_CoveringCommon - ThermalTransmittance: 0.608 kg/K/s3; FireRating: To BS EN 13501-1: 2018, Euroclass RtF B-s1,d0
Type - Pset_ManufacturerTypeInformation - Manufacturer: Kingspan Insulation
Classification: Pr_25_71_35_88, Pr_25_71_63_59 (Default Classification); n/a (Uniformat)
Pset_CoveringCommon - IsExternal: no; Reference: Basic Wall:KingspanInsulation_Insulation_Kooltherm-K118-Insulated-Plasterboard-42.5
Pset_EnvironmentalImpactIndicators - Reference: Basic Wall:KingspanInsulation_Insulation_Kooltherm-K118-Insulated-Plasterboard-42.5
Wall Schedule - Type: KingspanInsulation_Insulation_Kooltherm-K118-Insulated-Plasterboard-42.5; Version: 1; Export Type to IFC As: IfcCoveringType; Type IFC Predefined Type: USERDEFINED; ClassificationSystem: Uniclass; ClassificationCode: Pr_25_71_35_88, Pr_25_71_63_59; ClassificationTitle: Thermal laminate gypsum plasterboards, Phenolic foam boards; ClassificationVersion: 01/04/2023; Model: K118; Manufacturer: Kingspan Insulation; Type Comments: K118-42.5mm; URL: https://www.kingspan.com/gb/en/products/insulation-boards/wall-insulation-boards/kooltherm-k118-insulated-plasterboard/; Description: Insulated plasterboard for mechanically fixed and adhesively bonded insulated drylining.; Assembly Code: n/a; Type Mark: n/a; Fire Rating: To BS EN 13501-1: 2018, Euroclass RtF B-s1,d0; Length: 1200; Width: 43; Thickness: 42.5mm; ThermalConductivity: 0.019 (W/mK); BondedProductThermalConductivity: 0.19 (W/mK); InstallationGuidance: https://www.kingspan.com/content/dam/kingspan/kil/products/kooltherm-k118-insulated-plasterboard-gb-and-ireland/kingspan-kooltherm-k118-brochure-en-gb.pdf; HealthAndSafetyInformation: https://www.kingspan.com/content/dam/kingspan/kil/products/general-gb-and-ireland/kingspan-kooltherm-safety-information-en-gb-ie.pdf; ProductDataSheet: https://ks-kentico-prod-cdn-endpoint.azureedge.net/bimstorage/K118.42.5mm.BIM-1076.V1.pdf; ManufacturingFacility: This product is manufactured at Kingspan's Pembridge, Herefordshire manufacturing facility.
Other - Family: Basic Wall; Family and Type: Basic Wall: KingspanInsulation_Insulation_Kooltherm-K118-Insulated-Plasterboard-42.5; Type: KingspanInsulation_Insulation_Kooltherm-K118-Insulated-Plasterboard-42.5; Type Id: 307558
Constraints - Base Constraint: Level 0; Base Extension Distance: 0 mm; Base is Attached: no; Base Offset: 0 mm; Location Line: Wall Centerline; Related to Mass: no; Room Bounding: yes; Top Extension Distance: 0 mm; Top is Attached: no; Top Offset: 0 mm; Unconnected Height: 2400 mm
Dimensions - Area: 2.88 m2; Length: 1200 mm; Volume: 0.1224 m3
Phasing - Phase Created: New Construction
Structural - Structural: no; Structural Usage: Non-bearing
Cross-Section Definition - Cross-Section: Vertical

# IfcCovering: Walls : Basic Wall : KingspanInsulation_Insulation_Kooltherm-K118-Insulated-Plasterboard-52.5
In: Level 0
Type - PredefinedType: USERDEFINED; Material: KingspanInsulation01GB_Plasterboard_Kooltherm-K118-Insulated-Plasterboard-12.5 12.5 mm, KingspanInsulation01GB_Insulation_Kooltherm-K118-Insulated-Plasterboard-40 40 mm
Type - Other - Category: Walls; Family Name: Basic Wall
Type - Construction - Function: Interior; Wrapping at Inserts: Both; Width: 52.5 mm
Type - Dimensions - Length: 2400mm; Thickness: 52.5mm; Width: 1200mm
Type - Graphics - Coarse Scale Fill Pattern: <Solid fill>; Coarse Scale Fill Color: 12632256
Type - Identity Data - Assembly Code: n/a; BondedProductThermalConductivity: 0.19 (W/mK); ClassificationCode: Pr_25_71_35_88, Pr_25_71_63_59; ClassificationSystem: Uniclass; ClassificationTitle: Thermal laminate gypsum plasterboards, Phenolic foam boards; ClassificationVersion: 01/04/2023; Description: Insulated plasterboard for mechanically fixed and adhesively bonded insulated drylining.; Fire Rating: To BS EN 13501-1: 2018, Euroclass RtF B-s1,d0; HealthAndSafetyInformation: https://www.kingspan.com/content/dam/kingspan/kil/products/general-gb-and-ireland/kingspan-kooltherm-safety-information-en-gb-ie.pdf; InstallationGuidance: https://www.kingspan.com/content/dam/kingspan/kil/products/kooltherm-k118-insulated-plasterboard-gb-and-ireland/kingspan-kooltherm-k118-brochure-en-gb.pdf; Manufacturer: Kingspan Insulation; ManufacturingFacility: This product is manufactured at Kingspan's Pembridge, Herefordshire manufacturing facility.; Model: K118; ProductDataSheet: https://ks-kentico-prod-cdn-endpoint.azureedge.net/bimstorage/K118.52.5mm.BIM-1077.V1.pdf; ThermalConductivity: 0.019 (W/mK); Type Comments: K118-52.5mm; Type Mark: n/a; Type Name: KingspanInsulation_Insulation_Kooltherm-K118-Insulated-Plasterboard-52.5; URL: https://www.kingspan.com/gb/en/products/insulation-boards/wall-insulation-boards/kooltherm-k118-insulated-plasterboard/; Version: 1
Type - Analytical Properties - Absorptance: 0.7; Roughness: 3; Heat Transfer Coefficient (U): 0.460606 kg/K/s3; Thermal Mass: 0 kg/K/s2; Thermal Resistance (R): 2.17105 s3*K/kg
Type - Pset_CoveringCommon - ThermalTransmittance: 0.460606 kg/K/s3; FireRating: To BS EN 13501-1: 2018, Euroclass RtF B-s1,d0
Type - Pset_ManufacturerTypeInformation - Manufacturer: Kingspan Insulation
Classification: Pr_25_71_35_88, Pr_25_71_63_59 (Default Classification); n/a (Uniformat)
Pset_CoveringCommon - IsExternal: no; Reference: Basic Wall:KingspanInsulation_Insulation_Kooltherm-K118-Insulated-Plasterboard-52.5
Pset_EnvironmentalImpactIndicators - Reference: Basic Wall:KingspanInsulation_Insulation_Kooltherm-K118-Insulated-Plasterboard-52.5
Wall Schedule - Type: KingspanInsulation_Insulation_Kooltherm-K118-Insulated-Plasterboard-52.5; Version: 1; Export Type to IFC As: IfcCoveringType; Type IFC Predefined Type: USERDEFINED; ClassificationSystem: Uniclass; ClassificationCode: Pr_25_71_35_88, Pr_25_71_63_59; ClassificationTitle: Thermal laminate gypsum plasterboards, Phenolic foam boards; ClassificationVersion: 01/04/2023; Model: K118; Manufacturer: Kingspan Insulation; Type Comments: K118-52.5mm; URL: https://www.kingspan.com/gb/en/products/insulation-boards/wall-insulation-boards/kooltherm-k118-insulated-plasterboard/; Description: Insulated plasterboard for mechanically fixed and adhesively bonded insulated drylining.; Assembly Code: n/a; Type Mark: n/a; Fire Rating: To BS EN 13501-1: 2018, Euroclass RtF B-s1,d0; Length: 1200; Width: 53; Thickness: 52.5mm; ThermalConductivity: 0.019 (W/mK); BondedProductThermalConductivity: 0.19 (W/mK); InstallationGuidance: https://www.kingspan.com/content/dam/kingspan/kil/products/kooltherm-k118-insulated-plasterboard-gb-and-ireland/kingspan-kooltherm-k118-brochure-en-gb.pdf; HealthAndSafetyInformation: https://www.kingspan.com/content/dam/kingspan/kil/products/general-gb-and-ireland/kingspan-kooltherm-safety-information-en-gb-ie.pdf; ProductDataSheet: https://ks-kentico-prod-cdn-endpoint.azureedge.net/bimstorage/K118.52.5mm.BIM-1077.V1.pdf; ManufacturingFacility: This product is manufactured at Kingspan's Pembridge, Herefordshire manufacturing facility.
Other - Family: Basic Wall; Family and Type: Basic Wall: KingspanInsulation_Insulation_Kooltherm-K118-Insulated-Plasterboard-52.5; Type: KingspanInsulation_Insulation_Kooltherm-K118-Insulated-Plasterboard-52.5; Type Id: 307619
Constraints - Base Constraint: Level 0; Base Extension Distance: 0 mm; Base is Attached: no; Base Offset: 0 mm; Location Line: Wall Centerline; Related to Mass: no; Room Bounding: yes; Top Extension Distance: 0 mm; Top is Attached: no; Top Offset: 0 mm; Unconnected Height: 2400 mm
Dimensions - Area: 2.88 m2; Length: 1200 mm; Volume: 0.1512 m3
Phasing - Phase Created: New Construction
Structural - Structural: no; Structural Usage: Non-bearing
Cross-Section Definition - Cross-Section: Vertical

# IfcCovering: Walls : Basic Wall : KingspanInsulation_Insulation_Kooltherm-K118-Insulated-Plasterboard-57.5
In: Level 0
Type - PredefinedType: USERDEFINED; Material: KingspanInsulation01GB_Plasterboard_Kooltherm-K118-Insulated-Plasterboard-12.5 12.5 mm, KingspanInsulation01GB_Insulation_Kooltherm-K118-Insulated-Plasterboard-45 45 mm
Type - Other - Category: Walls; Family Name: Basic Wall
Type - Construction - Function: Interior; Wrapping at Inserts: Both; Width: 57.5 mm
Type - Dimensions - Length: 2400mm; Thickness: 57.5mm; Width: 1200mm
Type - Graphics - Coarse Scale Fill Pattern: <Solid fill>; Coarse Scale Fill Color: 12632256
Type - Identity Data - Assembly Code: n/a; BondedProductThermalConductivity: 0.19 (W/mK); ClassificationCode: Pr_25_71_35_88, Pr_25_71_63_59; ClassificationSystem: Uniclass; ClassificationTitle: Thermal laminate gypsum plasterboards, Phenolic foam boards; ClassificationVersion: 01/04/2023; Description: Insulated plasterboard for mechanically fixed and adhesively bonded insulated drylining.; Fire Rating: To BS EN 13501-1: 2018, Euroclass RtF B-s1,d0; HealthAndSafetyInformation: https://www.kingspan.com/content/dam/kingspan/kil/products/general-gb-and-ireland/kingspan-kooltherm-safety-information-en-gb-ie.pdf; InstallationGuidance: https://www.kingspan.com/content/dam/kingspan/kil/products/kooltherm-k118-insulated-plasterboard-gb-and-ireland/kingspan-kooltherm-k118-brochure-en-gb.pdf; Manufacturer: Kingspan Insulation; ManufacturingFacility: This product is manufactured at Kingspan's Pembridge, Herefordshire manufacturing facility.; Model: K118; ProductDataSheet: https://ks-kentico-prod-cdn-endpoint.azureedge.net/bimstorage/K118.57.5mm.BIM-1078.V1.pdf; ThermalConductivity: 0.019 (W/mK); Type Comments: K118-57.5mm; Type Mark: n/a; Type Name: KingspanInsulation_Insulation_Kooltherm-K118-Insulated-Plasterboard-57.5; URL: https://www.kingspan.com/gb/en/products/insulation-boards/wall-insulation-boards/kooltherm-k118-insulated-plasterboard/; Version: 1
Type - Analytical Properties - Absorptance: 0.7; Roughness: 3; Heat Transfer Coefficient (U): 0.410811 kg/K/s3; Thermal Mass: 0 kg/K/s2; Thermal Resistance (R): 2.43421 s3*K/kg
Type - Pset_CoveringCommon - ThermalTransmittance: 0.410811 kg/K/s3; FireRating: To BS EN 13501-1: 2018, Euroclass RtF B-s1,d0
Type - Pset_ManufacturerTypeInformation - Manufacturer: Kingspan Insulation
Classification: Pr_25_71_35_88, Pr_25_71_63_59 (Default Classification); n/a (Uniformat)
Pset_CoveringCommon - IsExternal: no; Reference: Basic Wall:KingspanInsulation_Insulation_Kooltherm-K118-Insulated-Plasterboard-57.5
Pset_EnvironmentalImpactIndicators - Reference: Basic Wall:KingspanInsulation_Insulation_Kooltherm-K118-Insulated-Plasterboard-57.5
Wall Schedule - Type: KingspanInsulation_Insulation_Kooltherm-K118-Insulated-Plasterboard-57.5; Version: 1; Export Type to IFC As: IfcCoveringType; Type IFC Predefined Type: USERDEFINED; ClassificationSystem: Uniclass; ClassificationCode: Pr_25_71_35_88, Pr_25_71_63_59; ClassificationTitle: Thermal laminate gypsum plasterboards, Phenolic foam boards; ClassificationVersion: 01/04/2023; Model: K118; Manufacturer: Kingspan Insulation; Type Comments: K118-57.5mm; URL: https://www.kingspan.com/gb/en/products/insulation-boards/wall-insulation-boards/kooltherm-k118-insulated-plasterboard/; Description: Insulated plasterboard for mechanically fixed and adhesively bonded insulated drylining.; Assembly Code: n/a; Type Mark: n/a; Fire Rating: To BS EN 13501-1: 2018, Euroclass RtF B-s1,d0; Length: 1200; Width: 58; Thickness: 57.5mm; ThermalConductivity: 0.019 (W/mK); BondedProductThermalConductivity: 0.19 (W/mK); InstallationGuidance: https://www.kingspan.com/content/dam/kingspan/kil/products/kooltherm-k118-insulated-plasterboard-gb-and-ireland/kingspan-kooltherm-k118-brochure-en-gb.pdf; HealthAndSafetyInformation: https://www.kingspan.com/content/dam/kingspan/kil/products/general-gb-and-ireland/kingspan-kooltherm-safety-information-en-gb-ie.pdf; ProductDataSheet: https://ks-kentico-prod-cdn-endpoint.azureedge.net/bimstorage/K118.57.5mm.BIM-1078.V1.pdf; ManufacturingFacility: This product is manufactured at Kingspan's Pembridge, Herefordshire manufacturing facility.
Other - Family: Basic Wall; Family and Type: Basic Wall: KingspanInsulation_Insulation_Kooltherm-K118-Insulated-Plasterboard-57.5; Type: KingspanInsulation_Insulation_Kooltherm-K118-Insulated-Plasterboard-57.5; Type Id: 307680
Constraints - Base Constraint: Level 0; Base Extension Distance: 0 mm; Base is Attached: no; Base Offset: 0 mm; Location Line: Wall Centerline; Related to Mass: no; Room Bounding: yes; Top Extension Distance: 0 mm; Top is Attached: no; Top Offset: 0 mm; Unconnected Height: 2400 mm
Dimensions - Area: 2.88 m2; Length: 1200 mm; Volume: 0.1656 m3
Phasing - Phase Created: New Construction
Structural - Structural: no; Structural Usage: Non-bearing
Cross-Section Definition - Cross-Section: Vertical

# IfcCovering: Walls : Basic Wall : KingspanInsulation_Insulation_Kooltherm-K118-Insulated-Plasterboard-62.5
In: Level 0
Type - PredefinedType: USERDEFINED; Material: KingspanInsulation01GB_Plasterboard_Kooltherm-K118-Insulated-Plasterboard-12.5 12.5 mm, KingspanInsulation01GB_Insulation_Kooltherm-K118-Insulated-Plasterboard-50 50 mm
Type - Other - Category: Walls; Family Name: Basic Wall
Type - Construction - Function: Interior; Wrapping at Inserts: Both; Width: 62.5 mm
Type - Dimensions - Length: 2400mm; Thickness: 62.5mm; Width: 1200mm
Type - Graphics - Coarse Scale Fill Pattern: <Solid fill>; Coarse Scale Fill Color: 12632256
Type - Identity Data - Assembly Code: n/a; BondedProductThermalConductivity: 0.19 (W/mK); ClassificationCode: Pr_25_71_35_88, Pr_25_71_63_59; ClassificationSystem: Uniclass; ClassificationTitle: Thermal laminate gypsum plasterboards, Phenolic foam boards; ClassificationVersion: 01/04/2023; Description: Insulated plasterboard for mechanically fixed and adhesively bonded insulated drylining.; Fire Rating: To BS EN 13501-1: 2018, Euroclass RtF B-s1,d0; HealthAndSafetyInformation: https://www.kingspan.com/content/dam/kingspan/kil/products/general-gb-and-ireland/kingspan-kooltherm-safety-information-en-gb-ie.pdf; InstallationGuidance: https://www.kingspan.com/content/dam/kingspan/kil/products/kooltherm-k118-insulated-plasterboard-gb-and-ireland/kingspan-kooltherm-k118-brochure-en-gb.pdf; Manufacturer: Kingspan Insulation; ManufacturingFacility: This product is manufactured at Kingspan's Pembridge, Herefordshire manufacturing facility.; Model: K118; ProductDataSheet: https://ks-kentico-prod-cdn-endpoint.azureedge.net/bimstorage/K118.62.5mm.BIM-1079.V1.pdf; ThermalConductivity: 0.019 (W/mK); Type Comments: K118-62.5mm; Type Mark: n/a; Type Name: KingspanInsulation_Insulation_Kooltherm-K118-Insulated-Plasterboard-62.5; URL: https://www.kingspan.com/gb/en/products/insulation-boards/wall-insulation-boards/kooltherm-k118-insulated-plasterboard/; Version: 1
Type - Analytical Properties - Absorptance: 0.7; Roughness: 3; Heat Transfer Coefficient (U): 0.370732 kg/K/s3; Thermal Mass: 0 kg/K/s2; Thermal Resistance (R): 2.69737 s3*K/kg
Type - Pset_CoveringCommon - ThermalTransmittance: 0.370732 kg/K/s3; FireRating: To BS EN 13501-1: 2018, Euroclass RtF B-s1,d0
Type - Pset_ManufacturerTypeInformation - Manufacturer: Kingspan Insulation
Classification: Pr_25_71_35_88, Pr_25_71_63_59 (Default Classification); n/a (Uniformat)
Pset_CoveringCommon - IsExternal: no; Reference: Basic Wall:KingspanInsulation_Insulation_Kooltherm-K118-Insulated-Plasterboard-62.5
Pset_EnvironmentalImpactIndicators - Reference: Basic Wall:KingspanInsulation_Insulation_Kooltherm-K118-Insulated-Plasterboard-62.5
Wall Schedule - Type: KingspanInsulation_Insulation_Kooltherm-K118-Insulated-Plasterboard-62.5; Version: 1; Export Type to IFC As: IfcCoveringType; Type IFC Predefined Type: USERDEFINED; ClassificationSystem: Uniclass; ClassificationCode: Pr_25_71_35_88, Pr_25_71_63_59; ClassificationTitle: Thermal laminate gypsum plasterboards, Phenolic foam boards; ClassificationVersion: 01/04/2023; Model: K118; Manufacturer: Kingspan Insulation; Type Comments: K118-62.5mm; URL: https://www.kingspan.com/gb/en/products/insulation-boards/wall-insulation-boards/kooltherm-k118-insulated-plasterboard/; Description: Insulated plasterboard for mechanically fixed and adhesively bonded insulated drylining.; Assembly Code: n/a; Type Mark: n/a; Fire Rating: To BS EN 13501-1: 2018, Euroclass RtF B-s1,d0; Length: 1200; Width: 63; Thickness: 62.5mm; ThermalConductivity: 0.019 (W/mK); BondedProductThermalConductivity: 0.19 (W/mK); InstallationGuidance: https://www.kingspan.com/content/dam/kingspan/kil/products/kooltherm-k118-insulated-plasterboard-gb-and-ireland/kingspan-kooltherm-k118-brochure-en-gb.pdf; HealthAndSafetyInformation: https://www.kingspan.com/content/dam/kingspan/kil/products/general-gb-and-ireland/kingspan-kooltherm-safety-information-en-gb-ie.pdf; ProductDataSheet: https://ks-kentico-prod-cdn-endpoint.azureedge.net/bimstorage/K118.62.5mm.BIM-1079.V1.pdf; ManufacturingFacility: This product is manufactured at Kingspan's Pembridge, Herefordshire manufacturing facility.
Other - Family: Basic Wall; Family and Type: Basic Wall: KingspanInsulation_Insulation_Kooltherm-K118-Insulated-Plasterboard-62.5; Type: KingspanInsulation_Insulation_Kooltherm-K118-Insulated-Plasterboard-62.5; Type Id: 307767
Constraints - Base Constraint: Level 0; Base Extension Distance: 0 mm; Base is Attached: no; Base Offset: 0 mm; Location Line: Wall Centerline; Related to Mass: no; Room Bounding: yes; Top Extension Distance: 0 mm; Top is Attached: no; Top Offset: 0 mm; Unconnected Height: 2400 mm
Dimensions - Area: 2.88 m2; Length: 1200 mm; Volume: 0.18 m3
Phasing - Phase Created: New Construction
Structural - Structural: no; Structural Usage: Non-bearing
Cross-Section Definition - Cross-Section: Vertical

# IfcCovering: Walls : Basic Wall : KingspanInsulation_Insulation_Kooltherm-K118-Insulated-Plasterboard-72.5
In: Level 0
Type - PredefinedType: USERDEFINED; Material: KingspanInsulation01GB_Plasterboard_Kooltherm-K118-Insulated-Plasterboard-12.5 12.5 mm, KingspanInsulation01GB_Insulation_Kooltherm-K118-Insulated-Plasterboard-60 60 mm
Type - Other - Category: Walls; Family Name: Basic Wall
Type - Construction - Function: Interior; Wrapping at Inserts: Both; Width: 72.5 mm
Type - Dimensions - Length: 2400mm; Thickness: 72.5mm; Width: 1200mm
Type - Graphics - Coarse Scale Fill Pattern: <Solid fill>; Coarse Scale Fill Color: 12632256
Type - Identity Data - Assembly Code: n/a; BondedProductThermalConductivity: 0.19 (W/mK); ClassificationCode: Pr_25_71_35_88, Pr_25_71_63_59; ClassificationSystem: Uniclass; ClassificationTitle: Thermal laminate gypsum plasterboards, Phenolic foam boards; ClassificationVersion: 01/04/2023; Description: Insulated plasterboard for mechanically fixed and adhesively bonded insulated drylining.; Fire Rating: To BS EN 13501-1: 2018, Euroclass RtF B-s1,d0; HealthAndSafetyInformation: https://www.kingspan.com/content/dam/kingspan/kil/products/general-gb-and-ireland/kingspan-kooltherm-safety-information-en-gb-ie.pdf; InstallationGuidance: https://www.kingspan.com/content/dam/kingspan/kil/products/kooltherm-k118-insulated-plasterboard-gb-and-ireland/kingspan-kooltherm-k118-brochure-en-gb.pdf; Manufacturer: Kingspan Insulation; ManufacturingFacility: This product is manufactured at Kingspan's Pembridge, Herefordshire manufacturing facility.; Model: K118; ProductDataSheet: https://ks-kentico-prod-cdn-endpoint.azureedge.net/bimstorage/K118.72.5mm.BIM-1080.V1.pdf; ThermalConductivity: 0.019 (W/mK); Type Comments: K118-72.5mm; Type Mark: n/a; Type Name: KingspanInsulation_Insulation_Kooltherm-K118-Insulated-Plasterboard-72.5; URL: https://www.kingspan.com/gb/en/products/insulation-boards/wall-insulation-boards/kooltherm-k118-insulated-plasterboard/; Version: 1
Type - Analytical Properties - Absorptance: 0.7; Roughness: 3; Heat Transfer Coefficient (U): 0.310204 kg/K/s3; Thermal Mass: 0 kg/K/s2; Thermal Resistance (R): 3.22368 s3*K/kg
Type - Pset_CoveringCommon - ThermalTransmittance: 0.310204 kg/K/s3; FireRating: To BS EN 13501-1: 2018, Euroclass RtF B-s1,d0
Type - Pset_ManufacturerTypeInformation - Manufacturer: Kingspan Insulation
Classification: Pr_25_71_35_88, Pr_25_71_63_59 (Default Classification); n/a (Uniformat)
Pset_CoveringCommon - IsExternal: no; Reference: Basic Wall:KingspanInsulation_Insulation_Kooltherm-K118-Insulated-Plasterboard-72.5
Pset_EnvironmentalImpactIndicators - Reference: Basic Wall:KingspanInsulation_Insulation_Kooltherm-K118-Insulated-Plasterboard-72.5
Wall Schedule - Type: KingspanInsulation_Insulation_Kooltherm-K118-Insulated-Plasterboard-72.5; Version: 1; Export Type to IFC As: IfcCoveringType; Type IFC Predefined Type: USERDEFINED; ClassificationSystem: Uniclass; ClassificationCode: Pr_25_71_35_88, Pr_25_71_63_59; ClassificationTitle: Thermal laminate gypsum plasterboards, Phenolic foam boards; ClassificationVersion: 01/04/2023; Model: K118; Manufacturer: Kingspan Insulation; Type Comments: K118-72.5mm; URL: https://www.kingspan.com/gb/en/products/insulation-boards/wall-insulation-boards/kooltherm-k118-insulated-plasterboard/; Description: Insulated plasterboard for mechanically fixed and adhesively bonded insulated drylining.; Assembly Code: n/a; Type Mark: n/a; Fire Rating: To BS EN 13501-1: 2018, Euroclass RtF B-s1,d0; Length: 1200; Width: 73; Thickness: 72.5mm; ThermalConductivity: 0.019 (W/mK); BondedProductThermalConductivity: 0.19 (W/mK); InstallationGuidance: https://www.kingspan.com/content/dam/kingspan/kil/products/kooltherm-k118-insulated-plasterboard-gb-and-ireland/kingspan-kooltherm-k118-brochure-en-gb.pdf; HealthAndSafetyInformation: https://www.kingspan.com/content/dam/kingspan/kil/products/general-gb-and-ireland/kingspan-kooltherm-safety-information-en-gb-ie.pdf; ProductDataSheet: https://ks-kentico-prod-cdn-endpoint.azureedge.net/bimstorage/K118.72.5mm.BIM-1080.V1.pdf; ManufacturingFacility: This product is manufactured at Kingspan's Pembridge, Herefordshire manufacturing facility.
Other - Family: Basic Wall; Family and Type: Basic Wall: KingspanInsulation_Insulation_Kooltherm-K118-Insulated-Plasterboard-72.5; Type: KingspanInsulation_Insulation_Kooltherm-K118-Insulated-Plasterboard-72.5; Type Id: 307828
Constraints - Base Constraint: Level 0; Base Extension Distance: 0 mm; Base is Attached: no; Base Offset: 0 mm; Location Line: Wall Centerline; Related to Mass: no; Room Bounding: yes; Top Extension Distance: 0 mm; Top is Attached: no; Top Offset: 0 mm; Unconnected Height: 2400 mm
Dimensions - Area: 2.88 m2; Length: 1200 mm; Volume: 0.2088 m3
Phasing - Phase Created: New Construction
Structural - Structural: no; Structural Usage: Non-bearing
Cross-Section Definition - Cross-Section: Vertical

# IfcCovering: Walls : Basic Wall : KingspanInsulation_Insulation_Kooltherm-K118-Insulated-Plasterboard-82.5
In: Level 0
Type - PredefinedType: USERDEFINED; Material: KingspanInsulation01GB_Plasterboard_Kooltherm-K118-Insulated-Plasterboard-12.5 12.5 mm, KingspanInsulation01GB_Insulation_Kooltherm-K118-Insulated-Plasterboard-70 70 mm
Type - Other - Category: Walls; Family Name: Basic Wall
Type - Construction - Function: Interior; Wrapping at Inserts: Both; Width: 82.5 mm
Type - Dimensions - Length: 2400mm; Thickness: 82.5mm; Width: 1200mm
Type - Graphics - Coarse Scale Fill Pattern: <Solid fill>; Coarse Scale Fill Color: 12632256
Type - Identity Data - Assembly Code: n/a; BondedProductThermalConductivity: 0.19 (W/mK); ClassificationCode: Pr_25_71_35_88, Pr_25_71_63_59; ClassificationSystem: Uniclass; ClassificationTitle: Thermal laminate gypsum plasterboards, Phenolic foam boards; ClassificationVersion: 01/04/2023; Description: Insulated plasterboard for mechanically fixed and adhesively bonded insulated drylining.; Fire Rating: To BS EN 13501-1: 2018, Euroclass RtF B-s1,d0; HealthAndSafetyInformation: https://www.kingspan.com/content/dam/kingspan/kil/products/general-gb-and-ireland/kingspan-kooltherm-safety-information-en-gb-ie.pdf; InstallationGuidance: https://www.kingspan.com/content/dam/kingspan/kil/products/kooltherm-k118-insulated-plasterboard-gb-and-ireland/kingspan-kooltherm-k118-brochure-en-gb.pdf; Manufacturer: Kingspan Insulation; ManufacturingFacility: This product is manufactured at Kingspan's Pembridge, Herefordshire manufacturing facility.; Model: K118; ProductDataSheet: https://ks-kentico-prod-cdn-endpoint.azureedge.net/bimstorage/K118.82.5mm.BIM-1081.V1.pdf; ThermalConductivity: 0.019 (W/mK); Type Comments: K118-82.5mm; Type Mark: n/a; Type Name: KingspanInsulation_Insulation_Kooltherm-K118-Insulated-Plasterboard-82.5; URL: https://www.kingspan.com/gb/en/products/insulation-boards/wall-insulation-boards/kooltherm-k118-insulated-plasterboard/; Version: 1
Type - Analytical Properties - Absorptance: 0.7; Roughness: 3; Heat Transfer Coefficient (U): 0.266667 kg/K/s3; Thermal Mass: 0 kg/K/s2; Thermal Resistance (R): 3.75 s3*K/kg
Type - Pset_CoveringCommon - ThermalTransmittance: 0.266667 kg/K/s3; FireRating: To BS EN 13501-1: 2018, Euroclass RtF B-s1,d0
Type - Pset_ManufacturerTypeInformation - Manufacturer: Kingspan Insulation
Classification: Pr_25_71_35_88, Pr_25_71_63_59 (Default Classification); n/a (Uniformat)
Pset_CoveringCommon - IsExternal: no; Reference: Basic Wall:KingspanInsulation_Insulation_Kooltherm-K118-Insulated-Plasterboard-82.5
Pset_EnvironmentalImpactIndicators - Reference: Basic Wall:KingspanInsulation_Insulation_Kooltherm-K118-Insulated-Plasterboard-82.5
Wall Schedule - Type: KingspanInsulation_Insulation_Kooltherm-K118-Insulated-Plasterboard-82.5; Version: 1; Export Type to IFC As: IfcCoveringType; Type IFC Predefined Type: USERDEFINED; ClassificationSystem: Uniclass; ClassificationCode: Pr_25_71_35_88, Pr_25_71_63_59; ClassificationTitle: Thermal laminate gypsum plasterboards, Phenolic foam boards; ClassificationVersion: 01/04/2023; Model: K118; Manufacturer: Kingspan Insulation; Type Comments: K118-82.5mm; URL: https://www.kingspan.com/gb/en/products/insulation-boards/wall-insulation-boards/kooltherm-k118-insulated-plasterboard/; Description: Insulated plasterboard for mechanically fixed and adhesively bonded insulated drylining.; Assembly Code: n/a; Type Mark: n/a; Fire Rating: To BS EN 13501-1: 2018, Euroclass RtF B-s1,d0; Length: 1200; Width: 83; Thickness: 82.5mm; ThermalConductivity: 0.019 (W/mK); BondedProductThermalConductivity: 0.19 (W/mK); InstallationGuidance: https://www.kingspan.com/content/dam/kingspan/kil/products/kooltherm-k118-insulated-plasterboard-gb-and-ireland/kingspan-kooltherm-k118-brochure-en-gb.pdf; HealthAndSafetyInformation: https://www.kingspan.com/content/dam/kingspan/kil/products/general-gb-and-ireland/kingspan-kooltherm-safety-information-en-gb-ie.pdf; ProductDataSheet: https://ks-kentico-prod-cdn-endpoint.azureedge.net/bimstorage/K118.82.5mm.BIM-1081.V1.pdf; ManufacturingFacility: This product is manufactured at Kingspan's Pembridge, Herefordshire manufacturing facility.
Other - Family: Basic Wall; Family and Type: Basic Wall: KingspanInsulation_Insulation_Kooltherm-K118-Insulated-Plasterboard-82.5; Type: KingspanInsulation_Insulation_Kooltherm-K118-Insulated-Plasterboard-82.5; Type Id: 307889
Constraints - Base Constraint: Level 0; Base Extension Distance: 0 mm; Base is Attached: no; Base Offset: 0 mm; Location Line: Wall Centerline; Related to Mass: no; Room Bounding: yes; Top Extension Distance: 0 mm; Top is Attached: no; Top Offset: 0 mm; Unconnected Height: 2400 mm
Dimensions - Area: 2.88 m2; Length: 1200 mm; Volume: 0.2376 m3
Phasing - Phase Created: New Construction
Structural - Structural: no; Structural Usage: Non-bearing
Cross-Section Definition - Cross-Section: Vertical

# IfcCovering: Walls : Basic Wall : KingspanInsulation_Insulation_Kooltherm-K118-Insulated-Plasterboard-92.5
In: Level 0
Type - PredefinedType: USERDEFINED; Material: KingspanInsulation01GB_Plasterboard_Kooltherm-K118-Insulated-Plasterboard-12.5 12.5 mm, KingspanInsulation01GB_Insulation_Kooltherm-K118-Insulated-Plasterboard-80 80 mm
Type - Other - Category: Walls; Family Name: Basic Wall
Type - Construction - Function: Interior; Wrapping at Inserts: Both; Width: 92.5 mm
Type - Dimensions - Length: 2400mm; Thickness: 92.5mm; Width: 1200mm
Type - Graphics - Coarse Scale Fill Pattern: <Solid fill>; Coarse Scale Fill Color: 12632256
Type - Identity Data - Assembly Code: n/a; BondedProductThermalConductivity: 0.19 (W/mK); ClassificationCode: Pr_25_71_35_88, Pr_25_71_63_59; ClassificationSystem: Uniclass; ClassificationTitle: Thermal laminate gypsum plasterboards, Phenolic foam boards; ClassificationVersion: 01/04/2023; Description: Insulated plasterboard for mechanically fixed and adhesively bonded insulated drylining.; Fire Rating: To BS EN 13501-1: 2018, Euroclass RtF B-s1,d0; HealthAndSafetyInformation: https://www.kingspan.com/content/dam/kingspan/kil/products/general-gb-and-ireland/kingspan-kooltherm-safety-information-en-gb-ie.pdf; InstallationGuidance: https://www.kingspan.com/content/dam/kingspan/kil/products/kooltherm-k118-insulated-plasterboard-gb-and-ireland/kingspan-kooltherm-k118-brochure-en-gb.pdf; Manufacturer: Kingspan Insulation; ManufacturingFacility: This product is manufactured at Kingspan's Pembridge, Herefordshire manufacturing facility.; Model: K118; ProductDataSheet: https://ks-kentico-prod-cdn-endpoint.azureedge.net/bimstorage/K118.92.5mm.BIM-1082.V1.pdf; ThermalConductivity: 0.019 (W/mK); Type Comments: K118-92.5mm; Type Mark: n/a; Type Name: KingspanInsulation_Insulation_Kooltherm-K118-Insulated-Plasterboard-92.5; URL: https://www.kingspan.com/gb/en/products/insulation-boards/wall-insulation-boards/kooltherm-k118-insulated-plasterboard/; Version: 1
Type - Analytical Properties - Absorptance: 0.7; Roughness: 3; Heat Transfer Coefficient (U): 0.233846 kg/K/s3; Thermal Mass: 0 kg/K/s2; Thermal Resistance (R): 4.27632 s3*K/kg
Type - Pset_CoveringCommon - ThermalTransmittance: 0.233846 kg/K/s3; FireRating: To BS EN 13501-1: 2018, Euroclass RtF B-s1,d0
Type - Pset_ManufacturerTypeInformation - Manufacturer: Kingspan Insulation
Classification: Pr_25_71_35_88, Pr_25_71_63_59 (Default Classification); n/a (Uniformat)
Pset_CoveringCommon - IsExternal: no; Reference: Basic Wall:KingspanInsulation_Insulation_Kooltherm-K118-Insulated-Plasterboard-92.5
Pset_EnvironmentalImpactIndicators - Reference: Basic Wall:KingspanInsulation_Insulation_Kooltherm-K118-Insulated-Plasterboard-92.5
Wall Schedule - Type: KingspanInsulation_Insulation_Kooltherm-K118-Insulated-Plasterboard-92.5; Version: 1; Export Type to IFC As: IfcCoveringType; Type IFC Predefined Type: USERDEFINED; ClassificationSystem: Uniclass; ClassificationCode: Pr_25_71_35_88, Pr_25_71_63_59; ClassificationTitle: Thermal laminate gypsum plasterboards, Phenolic foam boards; ClassificationVersion: 01/04/2023; Model: K118; Manufacturer: Kingspan Insulation; Type Comments: K118-92.5mm; URL: https://www.kingspan.com/gb/en/products/insulation-boards/wall-insulation-boards/kooltherm-k118-insulated-plasterboard/; Description: Insulated plasterboard for mechanically fixed and adhesively bonded insulated drylining.; Assembly Code: n/a; Type Mark: n/a; Fire Rating: To BS EN 13501-1: 2018, Euroclass RtF B-s1,d0; Length: 1200; Width: 93; Thickness: 92.5mm; ThermalConductivity: 0.019 (W/mK); BondedProductThermalConductivity: 0.19 (W/mK); InstallationGuidance: https://www.kingspan.com/content/dam/kingspan/kil/products/kooltherm-k118-insulated-plasterboard-gb-and-ireland/kingspan-kooltherm-k118-brochure-en-gb.pdf; HealthAndSafetyInformation: https://www.kingspan.com/content/dam/kingspan/kil/products/general-gb-and-ireland/kingspan-kooltherm-safety-information-en-gb-ie.pdf; ProductDataSheet: https://ks-kentico-prod-cdn-endpoint.azureedge.net/bimstorage/K118.92.5mm.BIM-1082.V1.pdf; ManufacturingFacility: This product is manufactured at Kingspan's Pembridge, Herefordshire manufacturing facility.
Other - Family: Basic Wall; Family and Type: Basic Wall: KingspanInsulation_Insulation_Kooltherm-K118-Insulated-Plasterboard-92.5; Type: KingspanInsulation_Insulation_Kooltherm-K118-Insulated-Plasterboard-92.5; Type Id: 307946
Constraints - Base Constraint: Level 0; Base Extension Distance: 0 mm; Base is Attached: no; Base Offset: 0 mm; Location Line: Wall Centerline; Related to Mass: no; Room Bounding: yes; Top Extension Distance: 0 mm; Top is Attached: no; Top Offset: 0 mm; Unconnected Height: 2400 mm
Dimensions - Area: 2.88 m2; Length: 1200 mm; Volume: 0.2664 m3
Phasing - Phase Created: New Construction
Structural - Structural: no; Structural Usage: Non-bearing
Cross-Section Definition - Cross-Section: Vertical

# Material: KingspanInsulation01GB_Plasterboard_Kooltherm-K118-Insulated-Plasterboard-12.5
Identity - Class: Generic
Structural - Name: KingspanInsulation_Plasterboard_Kooltherm-K118-Insulated-Plasterboard-12.5(1); Description: Plasterboard Layer for Kooltherm K118; Keywords: :Plasterboard: K118: Plaster; Type: Basic; Behavior: Isotropic
Thermal - Name: KingspanInsulation_Plasterboard_Kooltherm-K118-Insulated-Plasterboard-12.5(1); Description: Plasterboard Layer for Kooltherm K118; Keywords: :Plasterboard: K118: Plaster; Type: Solid; SubClass: Plaster; Source: Kingspan Insulation Ltd; Source URL: https://www.kingspan.com/gb/en/products/insulation-boards/; Density: 0 kg/m3; Emissivity: 0.01; Behavior: Isotropic; TransmitsLight: no; Permeability: 0 s/m; Reflectivity: 0; ElectricalResistivity: 0 kg*m3/s3/A2
Pset_MaterialCommon - Porosity: 0.001; MassDensity: 0 kg/m3
Pset_MaterialThermal - SpecificHeatCapacity: 100 m2/K/s2; ThermalConductivity: 0.19
Other - Category: Materials
Identity Data - Cost: 0; Description: Plasterboard Layer for Kooltherm K118; Manufacturer: Kingspan Insulation Ltd; Model: K118 Plaster; URL: https://www.kingspan.com/gb/en/products/insulation-boards/wall-insulation-boards/kooltherm-k118-insulated-plasterboard/
Materials and Finishes - Color: 13684944; Glow: no; Material Type: Other; Name: KingspanInsulation01GB_Plasterboard_Kooltherm-K118-Insulated-Plasterboard-12.5; Shininess: 64; Smoothness: 50; Transparency: 0

# Material: KingspanInsulation01GB_Insulation_Kooltherm-K118-Insulated-Plasterboard-25
Identity - Class: Generic
Thermal - Density: 0 kg/m3; Permeability: 0 s/m; Reflectivity: 0; Name: KingspanInsulation_Insulation_Kooltherm-K118-Insulated-Plasterboard(1); Description: Insulated plasterboard for mechanically fixed and adhesively bonded insulated drylining.; Keywords: Insulation: Phenolic: Rigid Insulation: Insulated Plasterboard; Type: Solid; Source: Kingspan Insulation Ltd; Source URL: https://www.kingspan.com/gb/en/products/insulation-boards/; Emissivity: 0.01; Behavior: Isotropic; TransmitsLight: no; ElectricalResistivity: 0 kg*m3/s3/A2
Pset_MaterialCommon - Porosity: 0.001
Pset_MaterialThermal - SpecificHeatCapacity: 1880 m2/K/s2; ThermalConductivity: 0.019
Other - Category: Materials
Identity Data - Comments: n/a; Cost: 0; Description: Insulated plasterboard for mechanically fixed and adhesively bonded insulated drylining.; Manufacturer: Kingspan Insulation Ltd; Model: K118-25mm; URL: https://www.kingspan.com/gb/en/products/insulation-boards/wall-insulation-boards/kooltherm-k118-insulated-plasterboard/
Materials and Finishes - Glow: no; Transparency: 0; Color: 8820953; Name: KingspanInsulation01GB_Insulation_Kooltherm-K118-Insulated-Plasterboard-25; Shininess: 64; Smoothness: 50

# Material: KingspanInsulation01GB_Insulation_Kooltherm-K118-Insulated-Plasterboard-30
Identity - Class: Generic
Thermal - Density: 0 kg/m3; Permeability: 0 s/m; Reflectivity: 0; Name: KingspanInsulation_Insulation_Kooltherm-K118-Insulated-Plasterboard(2); Description: Insulated plasterboard for mechanically fixed and adhesively bonded insulated drylining.; Keywords: Insulation: Phenolic: Rigid Insulation: Insulated Plasterboard; Type: Solid; Source: Kingspan Insulation Ltd; Source URL: https://www.kingspan.com/gb/en/products/insulation-boards/; Emissivity: 0.01; Behavior: Isotropic; TransmitsLight: no; ElectricalResistivity: 0 kg*m3/s3/A2
Pset_MaterialCommon - Porosity: 0.001
Pset_MaterialThermal - SpecificHeatCapacity: 1880 m2/K/s2; ThermalConductivity: 0.019
Other - Category: Materials
Identity Data - Comments: n/a; Cost: 0; Description: Insulated plasterboard for mechanically fixed and adhesively bonded insulated drylining.; Manufacturer: Kingspan Insulation Ltd; Model: K118-30mm; URL: https://www.kingspan.com/gb/en/products/insulation-boards/wall-insulation-boards/kooltherm-k118-insulated-plasterboard/
Materials and Finishes - Glow: no; Transparency: 0; Color: 8820953; Name: KingspanInsulation01GB_Insulation_Kooltherm-K118-Insulated-Plasterboard-30; Shininess: 64; Smoothness: 50

# Material: KingspanInsulation01GB_Insulation_Kooltherm-K118-Insulated-Plasterboard-40
Identity - Class: Generic
Thermal - Density: 0 kg/m3; Permeability: 0 s/m; Reflectivity: 0; Name: KingspanInsulation_Insulation_Kooltherm-K118-Insulated-Plasterboard(3); Description: Insulated plasterboard for mechanically fixed and adhesively bonded insulated drylining.; Keywords: Insulation: Phenolic: Rigid Insulation: Insulated Plasterboard; Type: Solid; Source: Kingspan Insulation Ltd; Source URL: https://www.kingspan.com/gb/en/products/insulation-boards/; Emissivity: 0.01; Behavior: Isotropic; TransmitsLight: no; ElectricalResistivity: 0 kg*m3/s3/A2
Pset_MaterialCommon - Porosity: 0.001
Pset_MaterialThermal - SpecificHeatCapacity: 1880 m2/K/s2; ThermalConductivity: 0.019
Other - Category: Materials
Identity Data - Comments: n/a; Cost: 0; Description: Insulated plasterboard for mechanically fixed and adhesively bonded insulated drylining.; Manufacturer: Kingspan Insulation Ltd; Model: K118-40mm; URL: https://www.kingspan.com/gb/en/products/insulation-boards/wall-insulation-boards/kooltherm-k118-insulated-plasterboard/
Materials and Finishes - Glow: no; Transparency: 0; Color: 8820953; Name: KingspanInsulation01GB_Insulation_Kooltherm-K118-Insulated-Plasterboard-40; Shininess: 64; Smoothness: 50

# Material: KingspanInsulation01GB_Insulation_Kooltherm-K118-Insulated-Plasterboard-45
Identity - Class: Generic
Thermal - Density: 0 kg/m3; Permeability: 0 s/m; Reflectivity: 0; Name: KingspanInsulation_Insulation_Kooltherm-K118-Insulated-Plasterboard(4); Description: Insulated plasterboard for mechanically fixed and adhesively bonded insulated drylining.; Keywords: Insulation: Phenolic: Rigid Insulation: Insulated Plasterboard; Type: Solid; Source: Kingspan Insulation Ltd; Source URL: https://www.kingspan.com/gb/en/products/insulation-boards/; Emissivity: 0.01; Behavior: Isotropic; TransmitsLight: no; ElectricalResistivity: 0 kg*m3/s3/A2
Pset_MaterialCommon - Porosity: 0.001
Pset_MaterialThermal - SpecificHeatCapacity: 1880 m2/K/s2; ThermalConductivity: 0.019
Other - Category: Materials
Identity Data - Comments: n/a; Cost: 0; Description: Insulated plasterboard for mechanically fixed and adhesively bonded insulated drylining.; Manufacturer: Kingspan Insulation Ltd; Model: K118-45mm; URL: https://www.kingspan.com/gb/en/products/insulation-boards/wall-insulation-boards/kooltherm-k118-insulated-plasterboard/
Materials and Finishes - Glow: no; Transparency: 0; Color: 8820953; Name: KingspanInsulation01GB_Insulation_Kooltherm-K118-Insulated-Plasterboard-45; Shininess: 64; Smoothness: 50

# Material: KingspanInsulation01GB_Insulation_Kooltherm-K118-Insulated-Plasterboard-50
Identity - Class: Generic
Thermal - Density: 0 kg/m3; Permeability: 0 s/m; Reflectivity: 0; Name: KingspanInsulation_Insulation_Kooltherm-K118-Insulated-Plasterboard(5); Description: Insulated plasterboard for mechanically fixed and adhesively bonded insulated drylining.; Keywords: Insulation: Phenolic: Rigid Insulation: Insulated Plasterboard; Type: Solid; Source: Kingspan Insulation Ltd; Source URL: https://www.kingspan.com/gb/en/products/insulation-boards/; Emissivity: 0.01; Behavior: Isotropic; TransmitsLight: no; ElectricalResistivity: 0 kg*m3/s3/A2
Pset_MaterialCommon - Porosity: 0.001
Pset_MaterialThermal - SpecificHeatCapacity: 1880 m2/K/s2; ThermalConductivity: 0.019
Other - Category: Materials
Identity Data - Comments: n/a; Cost: 0; Description: Insulated plasterboard for mechanically fixed and adhesively bonded insulated drylining.; Manufacturer: Kingspan Insulation Ltd; Model: K118-50mm; URL: https://www.kingspan.com/gb/en/products/insulation-boards/wall-insulation-boards/kooltherm-k118-insulated-plasterboard/
Materials and Finishes - Glow: no; Transparency: 0; Color: 8820953; Name: KingspanInsulation01GB_Insulation_Kooltherm-K118-Insulated-Plasterboard-50; Shininess: 64; Smoothness: 50

# Material: KingspanInsulation01GB_Insulation_Kooltherm-K118-Insulated-Plasterboard-60
Identity - Class: Generic
Thermal - Density: 0 kg/m3; Permeability: 0 s/m; Reflectivity: 0; Name: KingspanInsulation_Insulation_Kooltherm-K118-Insulated-Plasterboard(6); Description: Insulated plasterboard for mechanically fixed and adhesively bonded insulated drylining.; Keywords: Insulation: Phenolic: Rigid Insulation: Insulated Plasterboard; Type: Solid; Source: Kingspan Insulation Ltd; Source URL: https://www.kingspan.com/gb/en/products/insulation-boards/; Emissivity: 0.01; Behavior: Isotropic; TransmitsLight: no; ElectricalResistivity: 0 kg*m3/s3/A2
Pset_MaterialCommon - Porosity: 0.001
Pset_MaterialThermal - SpecificHeatCapacity: 1880 m2/K/s2; ThermalConductivity: 0.019
Other - Category: Materials
Identity Data - Comments: n/a; Cost: 0; Description: Insulated plasterboard for mechanically fixed and adhesively bonded insulated drylining.; Manufacturer: Kingspan Insulation Ltd; Model: K118-60mm; URL: https://www.kingspan.com/gb/en/products/insulation-boards/wall-insulation-boards/kooltherm-k118-insulated-plasterboard/
Materials and Finishes - Glow: no; Transparency: 0; Color: 8820953; Name: KingspanInsulation01GB_Insulation_Kooltherm-K118-Insulated-Plasterboard-60; Shininess: 64; Smoothness: 50

# Material: KingspanInsulation01GB_Insulation_Kooltherm-K118-Insulated-Plasterboard-70
Identity - Class: Generic
Thermal - Density: 0 kg/m3; Permeability: 0 s/m; Reflectivity: 0; Name: KingspanInsulation_Insulation_Kooltherm-K118-Insulated-Plasterboard(7); Description: Insulated plasterboard for mechanically fixed and adhesively bonded insulated drylining.; Keywords: Insulation: Phenolic: Rigid Insulation: Insulated Plasterboard; Type: Solid; Source: Kingspan Insulation Ltd; Source URL: https://www.kingspan.com/gb/en/products/insulation-boards/; Emissivity: 0.01; Behavior: Isotropic; TransmitsLight: no; ElectricalResistivity: 0 kg*m3/s3/A2
Pset_MaterialCommon - Porosity: 0.001
Pset_MaterialThermal - SpecificHeatCapacity: 1880 m2/K/s2; ThermalConductivity: 0.019
Other - Category: Materials
Identity Data - Comments: n/a; Cost: 0; Description: Insulated plasterboard for mechanically fixed and adhesively bonded insulated drylining.; Manufacturer: Kingspan Insulation Ltd; Model: K118-70mm; URL: https://www.kingspan.com/gb/en/products/insulation-boards/wall-insulation-boards/kooltherm-k118-insulated-plasterboard/
Materials and Finishes - Glow: no; Transparency: 0; Color: 8820953; Name: KingspanInsulation01GB_Insulation_Kooltherm-K118-Insulated-Plasterboard-70; Shininess: 64; Smoothness: 50

# Material: KingspanInsulation01GB_Insulation_Kooltherm-K118-Insulated-Plasterboard-80
Identity - Class: Generic
Thermal - Density: 0 kg/m3; Permeability: 0 s/m; Reflectivity: 0; Name: KingspanInsulation_Insulation_Kooltherm-K118-Insulated-Plasterboard(8); Description: Insulated plasterboard for mechanically fixed and adhesively bonded insulated drylining.; Keywords: Insulation: Phenolic: Rigid Insulation: Insulated Plasterboard; Type: Solid; Source: Kingspan Insulation Ltd; Source URL: https://www.kingspan.com/gb/en/products/insulation-boards/; Emissivity: 0.01; Behavior: Isotropic; TransmitsLight: no; ElectricalResistivity: 0 kg*m3/s3/A2
Pset_MaterialCommon - Porosity: 0.001
Pset_MaterialThermal - SpecificHeatCapacity: 1880 m2/K/s2; ThermalConductivity: 0.019
Other - Category: Materials
Identity Data - Comments: n/a; Cost: 0; Description: Insulated plasterboard for mechanically fixed and adhesively bonded insulated drylining.; Manufacturer: Kingspan Insulation Ltd; Model: K118-80mm; URL: https://www.kingspan.com/gb/en/products/insulation-boards/wall-insulation-boards/kooltherm-k118-insulated-plasterboard/
Materials and Finishes - Glow: no; Transparency: 0; Color: 8820953; Name: KingspanInsulation01GB_Insulation_Kooltherm-K118-Insulated-Plasterboard-80; Shininess: 64; Smoothness: 50
